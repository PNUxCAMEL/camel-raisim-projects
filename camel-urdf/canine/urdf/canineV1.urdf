Commit message: Add pdqp control test code

File: camel-urdf/canine/urdf/canineV1.urdf (robot description, URDF)
Before this commit: robot canine, 18 links, 17 joints
Links:
- link trunk: mass 10 -> 14.2
